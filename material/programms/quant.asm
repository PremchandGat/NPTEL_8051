ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL QUANT
HERE: SJMP HERE
ORG 130H
	QUANT:
	MOV R3,#08H
	MOV R0,#60H
	MOV R1,#70H
	LOOP:
	CLR C
	MOV A,@R0
	SUBB A,#0AH
	JNC LABEL1
	MOV @R1,#05H
	LJMP LOOP1
	
		
	LABEL1:
	CLR C
	MOV A,@R0
	SUBB A,#14H
	JNC LABEL2
	MOV @R1,#0FH
	LJMP LOOP1
	
	LABEL2:
	CLR C
	
	MOV A,@R0
	SUBB A,#1EH
	JNC LABEL3
	MOV @R1,#19H
	LJMP LOOP1
	
	LABEL3:
	MOV @R1,#23H
	LJMP LOOP1
	
	LOOP1:
	INC R0
	INC R1
	DJNZ R3,LOOP
	RET
END
	
	